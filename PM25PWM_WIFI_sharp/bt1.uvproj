# Keil uVision project bt1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: wifi +hex
  c flags: Optimize=8
  group Source Group 1
    ./: STARTUP.A51 main.c mydefine.h
